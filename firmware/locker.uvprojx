# Keil uVision project locker.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: locker +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\app;.\driver;.\bsp\tft_lcd;.\bsp\ld3320;.\bsp\syn6288;.\bsp\delay;.\bsp\usart;D:\Keil\ARM\Pack\Keil\STM32F4xx_DFP\1.0.8\Device\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: main.c app_ctx.c app_ui.c app_clock.c app_door.c app_voice.c app_cloud.c app_flow.c
  group driver
    ./driver/: pcf8574.c lock.c codebox.c keypad.c esp8266.c
  group bsp
    ./bsp/tft_lcd/: lcd.c touch.c font.c button.c hzfont.c
    ./bsp/ld3320/: ld3320.c
    ./bsp/syn6288/: syn6288.c
    ./bsp/delay/: Delay.c
    ./bsp/usart/: usart.c
  group stdperiph
    D:/Keil/ARM/Pack/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: stm32f4xx_flash.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
